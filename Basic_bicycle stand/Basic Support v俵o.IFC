Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Basic Support vélo.IFC
Time: 2020-07-03T11:01:47
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: BASI-SV-AS-002_Default
In: Default Storey
Material: S 235
PSet_Mass_Property - Mass Measure: 17.6113; Area Measure: 0.481563; Volume Measure: 0.00256668

# IfcBuildingElementProxy: BASI-SV-MUL-003_1000
In: Default Storey
Material: Alliage 1060
